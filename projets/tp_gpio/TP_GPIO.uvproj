# Keil uVision project TP_GPIO.uvproj, settings and files
target Simulation (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TP_GPIO
  group pilotes
    ../../pilotes/gpio/: gpio.c
    ../../pilotes/clock/: clock.c
    ../../pilotes/timer/: timer_1234.c
    ../../pilotes/adc/: adc.c
    ../../pilotes/usart/: usart.c
  group src
    ./src/: main.c
  group Boot
    C:/Keil/stm32lib/stm32f10x/boot/stm32f103/: startup-gcc.S
  group services
    ../../services/girouette/: girouette_service.c
    ../../services/moteur_cc/: moteur_cc_service.c
    ../../services/remote_fm/: remote_fn_service.c
    ../../services/servo_voile/: servo_voile_service.c
    ../../services/usart/: usart_service.c
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: TP_GPIO
  AfterMake: "C:\Program Files (x86)\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" release\*.elf
